# IAR project unitek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; DEBUG; NO_WATCHDOG
  ICCARM.CCDiagSuppress: Pe236, Pa050, Pa082, Pa089
  ICCARM.PreInclude: mbcmpvar.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; menu; display; tools; drivers; freertos\portable; freertos\include; stlib\STM32F10x_StdPeriph_Driver\inc; stlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: freertos\include; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: unitek.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: gBanner; fw_version
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; WATCHDOG; IAP
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: unitek.bin
  postbuild: $TOOLKIT_DIR$\spbin.exe -x 20a -f "$TARGET_BPATH$.bin" -o "$TARGET_BPATH$.spb"
  ILINK.IlinkIcfFile: stm32f10x_flash-iap.icf
configuration DebugJL (ARM, debug)
  as the first configuration, except:
  group Application
    ./: main.c meas.c parser.c version.c
  group Application/Menu
    menu/: Menu.c menustrings.c Submenu.c SubSubMenu.c VariabiliGlobali_di_Lavoro.c
  group Display
    display/: BitmapsImmagini.c Conversioni.c Display_128x64.c Display_128x64_DrawFunctions.c Display_128x64_low_level.c display_interface.c
  group Display/Fonts
    display/: fontscalibri10.c fontscalibri20.c fontscambria10pt.c fontscambria12pt.c fontscambria16pt.c
  group Drivers
    drivers/: ad5934.c bsp.c eeprom.c ffile.c i2c.c keyboard.c mspi.c usart1.c usart2.c usart3.c
  group FreeRTOS
    freertos/: list.c queue.c
  group FreeRTOS/MemMang
    freertos/MemMang/: myheap.c
  group FreeRTOS/Portable
    freertos/portable/: port.c portasm.s
  group STLib/CMSIS
    drivers/: startup_stm32f10x_cl.s
    stlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STLib/StdPeriph
    stlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c
  group Tools
    Tools/: backup.c config.c crc16.c datetime.c debug.c tools.c ymodem.c
    freertos/: tasks.c
