<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\unitek.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All targets</name>
      <member>
        <project>unitek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>unitek</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


